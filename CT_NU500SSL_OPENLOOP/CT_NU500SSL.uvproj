# Keil uVision project CT_NU500SSL.uvproj, settings and files
target CT_NU500SSL (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: CT_NU500SSL +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\INC
  group SRC
    ./SRC/: Common.c Delay.c main.c
  group INC
    ./INC/: Common.h Delay.h Function_Define.h main.h MS51.h SFR_Macro.h
  group Startup
    ./Startup/: STARTUP.A51
