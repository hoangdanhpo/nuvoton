# Keil uVision project MS51_Tatoo_Machine.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: MS51_Tatoo_Machine +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\INC
  group SRC
    ./SRC/: Common.c Delay.c main.c HW_init.c oled_i2c.c
  group INC
    ./INC/: Common.h Delay.h Function_Define.h main.h MS51.h SFR_Macro.h logo.h oled_i2c.h oledfont.h HW_init.h
  group Startup
    ./Startup/: STARTUP.A51
