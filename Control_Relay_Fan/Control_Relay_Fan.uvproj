# Keil uVision project Control_Relay_Fan.uvproj, settings and files
target Control_Relay_Fan (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Control_Relay_Fan +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\INC
  group SRC
    ./SRC/: Common.c Delay.c main.c adc.c
  group INC
    ./INC/: Common.h Delay.h Function_Define.h main.h MS51.h SFR_Macro.h
  group Startup
    ./Startup/: STARTUP.A51
